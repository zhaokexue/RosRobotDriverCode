# Keil uVision project MBOT.uvprojx, settings and files
target MBOT (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MBOT +hex
  c flags: Optim=1
  c define: STM32F10X_ HD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\STM32F10x_FWLib\inc;..\SYSTEM;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\Mbot_COER;..\Mbot_HARDWARE;..\mbot\CONTROL;..\mbot\DMP;..\mbot\filter;..\mbot\MPU6050;..\mbot\show;..\mbot\usart;..\Mbot_HARDWARE\ADC;..\Mbot_HARDWARE\DMP;..\Mbot_HARDWARE\ENCODER;..\Mbot_HARDWARE\EXTI;..\Mbot_HARDWARE\IIC;..\Mbot_HARDWARE\KEY;..\Mbot_HARDWARE\LED;..\Mbot_HARDWARE\MPU6050;..\Mbot_HARDWARE\USART3;..\Mbot_HARDWARE\MOTOR;..\mbot\PID;..\Mbot_HARDWARE\OLED;..\Mbot_HARDWARE\TIMER
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: stm32f10x_it.c system_stm32f10x.c MBOT.c
  group CORE
    ../Mbot_COER/: core_cm3.c startup_stm32f10x_md.s
  group FWLIB
    ../STM32F10x_FWLib/src/: stm32f10x_adc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_rcc.c misc.c stm32f10x_exti.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group MBOT_HAREWARE
    ../Mbot_HARDWARE/LED/: LED.C
    ../Mbot_HARDWARE/ADC/: adc.c
    ../Mbot_HARDWARE/MOTOR/: motor.c
    ../Mbot_HARDWARE/ENCODER/: encoder.c
    ../Mbot_HARDWARE/IIC/: IOI2C.c
    ../Mbot_HARDWARE/USART3/: usart3.c
    ../Mbot_HARDWARE/EXTI/: exti.c
    ../Mbot_HARDWARE/KEY/: key.c
  group MBOT
    ../mbot/CONTROL/: control.c
    ../mbot/DMP/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../mbot/MPU6050/: MPU6050.c
    ../mbot/show/: show.c
    ../mbot/usart/: mbotLinuxUsart.c
    ../mbot/PID/: pid.c
